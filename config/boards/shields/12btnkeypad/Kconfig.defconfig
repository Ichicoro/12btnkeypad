## config/boards/shields/12btnkeypad/Kconfig.defconfig
```kconfig
if SHIELD_12BTNKEYPAD

config ZMK_KEYBOARD_NAME
    default "12btnkeypad"

endif
```
